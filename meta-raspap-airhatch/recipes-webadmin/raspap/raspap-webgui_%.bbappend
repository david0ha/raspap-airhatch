require ${@bb.utils.contains('DISTRO_FEATURES', 'airhatch', 'raspap-webgui-airhatch.inc', '', d)}
